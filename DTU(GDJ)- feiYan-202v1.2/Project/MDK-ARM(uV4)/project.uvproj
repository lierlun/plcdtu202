# Keil uVision project project.uvproj, settings and files
target Flash (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: output +hex
  AfterMake: CopyHex_Flash.bat
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c misc: --diag_suppress=870
  c include: ..\..\Libraries\CMSIS\Device\ST\STM32F10x\Include;..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\User\bsp;..\..\User\bsp\inc;..\..\User;..\..\Libraries\CMSIS\Include;..\..\uCOS-III\uC-CPU;..\..\uCOS-III\uC-CPU\ARM-Cortex-M3\RealView;..\..\uCOS-III\uC-LIB;..\..\uCOS-III\uC-LIB\Ports\ARM-Cortex-M3\RealView;..\..\uCOS-III\uCOS-III\Source;..\..\uCOS-III\uCOS-III\Ports\ARM-Cortex-M3\RealView;..\..\Malloc;..\..\User\Modbus
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group User
    ../../User/: app.c cpu_bsp.c os_app_hooks.c main.c my_stdlib.c data.c filter.c luat_air208.c NetMessage.c cJSON.c
    ../../User/Modbus/: crc.c modbus_gprs_iccid.c modbus_485.c queue.c Trans_queue.c
  group BSP
    ../../User/bsp/: stm32f10x_it.c stm32f10x_assert.c bsp.c bsp_os.c
    ../../User/bsp/src/: param.c bsp_iwdg.c bsp_led.c bsp_uart.c bsp_timer.c bsp_ds18b20.c bsp_spi_flash.c bsp_spi_bus.c bsp_din.c bsp_dout.c bsp_cpu_rtc.c bsp_cpu_flash.c
  group MDK-ARM
    ../../Libraries/CMSIS/Device/ST/STM32F10x/Source/Templates/arm/: startup_stm32f10x_hd.s
  group StdPeriph_Driver
    ../../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_bkp.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_sdio.c stm32f10x_dma.c stm32f10x_crc.c stm32f10x_iwdg.c stm32f10x_rtc.c
  group CMSIS
    ../../User/bsp/: system_stm32f10x.c
  group uC/CPU
    ../../uCOS-III/uC-CPU/: cpu_cache.h cpu_core.c cpu_core.h cpu_def.h
    ../../uCOS-III/uC-CPU/ARM-Cortex-M3/RealView/: cpu.h cpu_a.asm cpu_c.c
  group uC/LIB
    ../../uCOS-III/uC-LIB/: lib_ascii.c lib_ascii.h lib_def.h lib_math.c lib_math.h lib_mem.c lib_mem.h lib_str.c lib_str.h
    ../../uCOS-III/uC-LIB/Ports/ARM-Cortex-M3/RealView/: lib_mem_a.asm
  group uC/OS-III Source
    ../../uCOS-III/uCOS-III/Source/: os.h os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_mon.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_type.h os_var.c
  group uC/OS-III Port
    ../../uCOS-III/uCOS-III/Ports/ARM-Cortex-M3/RealView/: os_cpu.h os_cpu_a.s os_cpu_c.c
  group Malloc
    ../../Malloc/: malloc.c GprsQueue.c
